Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2016-09-06T09:17:42
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.12.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Sep 06 09:17:42 2016* Host: NCL-TA29* Database: C:\Users\Vickersc\AppData\Local\Temp\{F5C8C2AA-4106-44DD-9842-B87F3BA0F415}\ifc* Database version: 5507* Database creation date: Tue Sep 06 09:17:41 2016* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Sep 06 09:17:42 2016* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Sep 06 09:17:42 2016* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionControlElement: MasterOccupancySensorHead, NBS_FlexConnectorsLtd_ExtrLowVltgOccpncyDtctrs_Fex7ZoneLiteMasterOccupancySensorHead:MasterOccupancySensorHead:245505
In: Level 0
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_70_70_47_28 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FlexConnectorsLtd_ExtraLowVoltageOccupancyDetectors_flex7ZoneLiteMasterOccupancySensorHead; ManufacturerName: Flex Connectors Ltd; ManufacturerURL: www.flexconnectors.co.uk; NBSCertification: http://www.nationalbimlibrary.com/cert/ovhcl5kl; NBSDescription: Extra-low voltage occupancy detectors; NBSReference: 90-65-05/420; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.flexconnectors.co.uk/products/zone-control/zonelite-sensor-heads; Revision: n/a; Uniclass2015Title: Extra low voltage occupancy detectors; Uniclass2015Code: Pr_70_70_47_28; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - EquipmentInterconnectivity: Wired; Format: Passive infrared; OccupancySensitivity: Adjustable; Range: Fixed; FieldOfView: Fixed; RemoteSetupOverride: By infrared controller; Mounting: n/a; IngressProtectionMinimum: IP20; AdjustableSensorSettings: Not required; MountingOptions: Ceiling, flush, surface; SensorRange: 7.42 m x 5.66 m at 2.5 m height; OperatingTemperatureRange: -10 to 40°C
Type - Pset_SensorTypeMovementSensor - MovementSensingType: PIR; TimeConstant: 0
Type - Pset_SensorTypeLightSensor - LightSensorAccuracy: 0; LightSensorRange: 0.0 , 0.0; LightSensorSetPoint: 0; TimeConstant: 0
Type - IFC - IfcExportAs: IfcSensorType; IfcExportType: MOVEMENTSENSOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_70_47_28:Extra low voltage occupancy detectors; CodePerformance: LVD-2006/95/EC: EMC-2004/108/EC; Color: White, red; Constituents: n/a; Description: The PIR (passive infra-red) detector senses movement and sends the information back to the Lighting Control Pack; DurationUnit: year; ExpectedLife: n/a; Features: Discreet sensor head, additional heads may be added to increase range up to 6 fold; Finish: n/a; Grade: n/a; Material: Nylon - PA6 UL94 V-0 rated; Manufacturer: info@flexconnectors.co.uk; ModelNumber: fzh/pir; ModelReference: ZoneLite Master Occupancy Sensor Head; Name: ExtraLowVoltageOccupancyDetectors_flex7ZoneLiteMasterOccupancySensorHead_FlexConnectorsLtd; ReplacementCost: n/a; Shape: Cylindrical; Size: Ø 40 x 33.2 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
